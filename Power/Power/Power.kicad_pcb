# Repository leeyoung7017/sonometer

File readme.md:

分贝是用来测量声音强度大小的单位。其中SPL的含义为声压级(Sound Pressure Level)，这一参数是国家计量部门用来校准各种听力仪器的基准值，如果用常规的测听耳机测试时，纯音听力计必须要输出7.5dB SPL，才能使1000Hz的纯音信号达到0dB HL。

纯音的声强要用“dB HL”表示，HL的意思是听力级(Hearing Level)

| Hz   | dB SPL->0dB HL |
| ---- | -------------- |
| 250  | 25.5           |
| 500  | 11.5           |
| 1000 | 7.0            |
| 2000 | 6.5            |
| 4000 | 10.0           |
| 8000 | 13.0           |

dB SPL存在计算公式
$$
I(dB) = 10 \times log_{10}(\frac{P^2}{P_{ref}^2}) = 20 \times log_{10}(\frac{P}{P_{ref}})
$$
其中，P是声压测量值，P<sub>ref</sub>是标准值(0 dB SPL)。这里选择的声压基准值为2*e-5Pa，这是人耳在1KHz这个频率下能听到的最小的声音。将标准值带入上公式中：
$$
I(dB) = 20 \times log_{10}(\frac{P}{2\times10^{-5}})
$$
前面的几个被测量都是模拟量，在数字时代更多的音频分贝表示是dBFS。dBFS的全称为Decibels Full Scale，全分贝刻度，是数字音频分贝值的表示方法。和模拟量度量声音强度不同的是，dBFS的基准值并不是最小的或者是中间的某一个值，是**最大**的那个值！也就是说0dBFS是数字设备能达到的最大值，除了最大值外都是负值。
$$
dBFS = 20 \times log_{10}（\frac{sample}{2^{bits}}）
$$
其中，bits为采样位深，以该项目为例，bits=24，将值带入上公式中：
$$
dBFS = 20 \times log_{10}（\frac{sample}{2^{24}}）= 20 \times log_{10}（\frac{sample}{16,777,216}）
$$

## KiCad design Power/Power/Power.kicad_pcb

Parts:
C5, C9, C10, C29: 10n; C_0805_2012Metric
C6, C14, C16, C18, C20, C22, C24, C26, C27, C31: 0.1u; C_0805_2012Metric
C7, C13, C15, C17, C28: 10u; C_0805_2012Metric
C8: 220u; C_0805_2012Metric
C19, C21, C23, C25, C30: 100u; C_0805_2012Metric
D2, D4, D5, D6: SS34; D_0805_2012Metric
D3: SS54; D_0805_2012Metric
J1, J3: Conn_01x03; PhoenixContact_MC_1,5_3-G-5.08_1x03_P5.08mm_Horizontal
J2: Barrel_Jack_Switch; BarrelJack_Horizontal
J4, J5, J6: Conn_01x02; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
L2, L4, L5, L6: 10u; L_7.3x7.3_H3.5
L3: 33u; L_7.3x7.3_H3.5
R5: 1.1k; R_0805_2012Metric
R6, R8, R10, R11: 10k; R_0805_2012Metric
R7, R9: 3.24k; R_0805_2012Metric
R12: 4.87k; R_0805_2012Metric
RV1: R_Potentiometer; Potentiometer_Bourns_3296W_Vertical
S1: R1966ABLKBLKGR; SW_R1966ABLKBLKGR; PARTREV E
U3, U5, U6, U7: TPS5430DDAR; CONV_TPS5430DDAR; PARTREV I
U4: LM2596S-ADJ; TO-263-5_TabPin3

Connections:
7V5: C6.2, C8.1, J5.1, L3.2, RV1.1
12V0: C7.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C27.1, C28.1, J1.1, S1.1, U3.7 (VIN), U4.1 (VIN), U5.7 (VIN), U6.7 (VIN), U7.7 (VIN)
GND: C7.2, C8.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.2, C25.1, C26.2, C27.2, C28.2, C30.1, C31.2, D3.2 (A), D4.2 (A), J1.2, J2.2, J2.3, J3.2, J4.2, J5.2, J6.2, L2.2, L4.2, L6.2, R6.2, R7.2, R10.2, R11.2, RV1.3, U4.3 (GND), U4.5 (~ON/OFF), U5.6 (GND), U5.9 (POWERPAD), U5.10, U5.11, U5.12, U5.13, U5.14, U5.15
unnamed: C5.1, U3.1 (BOOT)
unnamed: C5.2, D2.1 (K), L2.1, U3.8 (PH)
unnamed: C6.1, RV1.2, U4.4 (FB)
unnamed: C9.1, U5.1 (BOOT)
unnamed: C9.2, D4.1 (K), L5.1, U5.8 (PH)
unnamed: C10.1, U6.1 (BOOT)
unnamed: C10.2, D5.1 (K), L4.1, U6.8 (PH)
unnamed: C29.1, U7.1 (BOOT)
unnamed: C29.2, D6.1 (K), L6.1, U7.8 (PH)
unnamed: D3.1 (K), L3.1, U4.2 (OUT)
unnamed: J2.1, S1.1A
unnamed: R5.1, R6.1, U3.4 (VSENSE)
unnamed: R7.1, R8.1, U5.4 (VSENSE)
unnamed: R9.1, R10.1, U6.4 (VSENSE)
unnamed: R11.1, R12.1, U7.4 (VSENSE)
VOUT_+5V: C23.1, C24.1, J3.1, J4.1, L5.2, R8.2
VOUT_-2.5V: C30.2, C31.1, D6.2 (A), J6.1, R12.2, U7.6 (GND), U7.9 (POWERPAD), U7.10, U7.11, U7.12, U7.13, U7.14, U7.15
VOUT_-5V: C25.2, C26.1, D5.2 (A), J3.3, R9.2, U6.6 (GND), U6.9 (POWERPAD), U6.10, U6.11, U6.12, U6.13, U6.14, U6.15
VOUT_-12V: C21.2, C22.1, D2.2 (A), J1.3, R5.2, U3.6 (GND), U3.9 (POWERPAD), U3.10, U3.11, U3.12, U3.13, U3.14, U3.15

Notes on the sheet:
DCDC_12V_±5V
DCDC_12V0_ADJ
SONOMETER_POWER
2022.10.15
FB线远离电感，可以打接地过孔屏蔽
输出端口
肖特基二极管 40V 5A
DCDC_12V_-2.5V

Board: 2 copper layers, 78.7 x 68.2 mm, 56 parts (0 on the bottom side), 22 nets.

File Power/Power/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C20,C_0805_2012Metric,1,0.1u,
C19,C_0805_2012Metric,1,100u,
RV1,Potentiometer_Bourns_3296W_Vertical,1,R_Potentiometer,
J4,"PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal",1,Conn_01x02,
S1,SW_R1966ABLKBLKGR,1,R1966ABLKBLKGR,
U7,CONV_TPS5430DDAR,1,TPS5430DDAR,
L2,L_7.3x7.3_H3.5,1,10u,
C31,C_0805_2012Metric,1,0.1u,
L4,L_7.3x7.3_H3.5,1,10u,
R8,R_0805_2012Metric,1,10k,
C13,C_0805_2012Metric,1,10u,
C25,C_0805_2012Metric,1,100u,
C10,C_0805_2012Metric,1,10n,
U3,CONV_TPS5430DDAR,1,TPS5430DDAR,
_4,,1,,
R12,R_0805_2012Metric,1,4.87k,
C24,C_0805_2012Metric,1,0.1u,
J1,"PhoenixContact_MC_1,5_3-G-5.08_1x03_P5.08mm_Horizontal",1,Conn_01x03,
_3,,1,,
C14,C_0805_2012Metric,1,0.1u,
R6,R_0805_2012Metric,1,10k,
J5,"PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal",1,Conn_01x02,
C7,C_0805_2012Metric,1,10u,
R11,R_0805_2012Metric,1,10k,
_2,,1,,
C22,C_0805_2012Metric,1,0.1u,
C15,C_0805_2012Metric,1,10u,
U6,CONV_TPS5430DDAR,1,TPS5430DDAR,
C5,C_0805_2012Metric,1,10n,
D2,D_0805_2012Metric,1,SS34,
R7,R_0805_2012Metric,1,3.24k,
C30,C_0805_2012Metric,1,100u,
C27,C_0805_2012Metric,1,0.1u,
C9,C_0805_2012Metric,1,10n,
C23,C_0805_2012Metric,1,100u,
C21,C_0805_2012Metric,1,100u,
C6,C_0805_2012Metric,1,0.1u,
C16,C_0805_2012Metric,1,0.1u,
D6,D_0805_2012Metric,1,SS34,
D4,D_0805_2012Metric,1,SS34,
C8,C_0805_2012Metric,1,220u,
U5,CONV_TPS5430DDAR,1,TPS5430DDAR,
C17,C_0805_2012Metric,1,10u,
J6,"PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal",1,Conn_01x02,
L6,L_7.3x7.3_H3.5,1,10u,
C29,C_0805_2012Metric,1,10n,
J2,BarrelJack_Horizontal,1,Barrel_Jack_Switch,
U4,TO-263-5_TabPin3,1,LM2596S-ADJ,
C26,C_0805_2012Metric,1,0.1u,
C28,C_0805_2012Metric,1,10u,
J3,"PhoenixContact_MC_1,5_3-G-5.08_1x03_P5.08mm_Horizontal",1,Conn_01x03,
D3,D_0805_2012Metric,1,SS54,
C18,C_0805_2012Metric,1,0.1u,
R10,R_0805_2012Metric,1,10k,
,,1,,
L5,L_7.3x7.3_H3.5,1,10u,
R9,R_0805_2012Metric,1,3.24k,
L3,L_7.3x7.3_H3.5,1,33u,
R5,R_0805_2012Metric,1,1.1k,
D5,D_0805_2012Metric,1,SS34,

## Commit log

2021-12-23 add ad7767 EXTI enable or not 2021.12.23
2021-12-30 modify external clock 25M ---> 8M 2021.12.30
2022-01-13 sonometer Code encryption 2022.1.13
2022-01-15 sonometer Code HMI 2022.1.15
2022-03-08 添加灵活的时间长度播放，解析指令
2022-10-19 调试AD7767
