# Keil uVision project Fire_H7.uvprojx, settings and files
target Fire_H7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_H7
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,APPLICATION_ADDRESS=0x8000000
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\BSP\lan8720a;..\..\User\BSP\led;..\..\User\BSP\i2s;..\..\User\BSP\usart;..\..\User\APP;..\..\User\lwip-2.0.3\src\include;..\..\User\lwip-2.0.3\system;..\..\User\BSP\timer;..\..\User\BSP\key;..\..\User\BSP\udp_demo;..\..\User\lwip-2.0.3\src\include\lwip;..\..\User\lwip-2.0.3\src\include\netif;..\..\User\lwip-2.0.3\src\include\posix;..\..\User\lwip-2.0.3\src\include\lwip\apps;..\..\User\lwip-2.0.3\src\include\lwip\priv;..\..\User\lwip-2.0.3\src\include\posix;..\..\User\BSP\ad7767;..\..\TEST\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_eth.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart_ex.c
  group USER
    ../../User/: main.c stm32h7xx_it.c
    ../../User/APP/: app_ethernet.c ethernetif.c
    ../../User/delay/: core_delay.c
  group BSP
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/LAN8720a/: LAN8720a.c
    ../../User/BSP/i2s/: bsp_i2s.c bsp_i2s_data.c
    ../../User/BSP/timer/: timer.c
    ../../User/BSP/key/: bsp_key.c
    ../../User/BSP/udp_demo/: udp_demo.c
    ../../User/BSP/ad7767/: ad7767.c
  group TEST
    ../../TEST/usart/: bsp_debug_usart.c
  group LwIP_src_api
    ../../User/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_src_netif
    ../../User/lwip-2.0.3/src/netif/: ethernet.c
  group LwIP_src_core
    ../../User/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LwIP_src_core_ipv4
    ../../User/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group DOC
    ../../Doc/: readme.txt
